Commit message: fix description

File: src/ros2_com/descriptions/stolzenberg_description.urdf (robot description, URDF)
Before this commit: robot stolzenberg, 5 links, 4 joints
Joints:
- joint lidar_joint: origin xyz=0.83 0 0.2335 rpy=0 0 ${pi} -> xyz=0.83 0 0.2335 rpy=0 0 0
